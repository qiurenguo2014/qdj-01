# Keil uVision project prj.uvproj, settings and files
target MK60D10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output ..\Firmware\project.bin .\OBJ\project.axf
  c flags: Optim=2
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group APP
    ../code/: main.c
    ../code/APP/signal/: sig_process.c fft.c FLY.C
    ../code/APP/menu/: usermenu.c
    ../code/APP/Wifi/: RF.c Protocol.c CRC.c
  group gui
    ../code/GUI/: asc16.c asc32.c ConvertColor.c GUI_BASIC.C gui_font.c gui_keyboard.c GUI_StockC.C hzk16.c hzk24.c hzk32.c lcddrive.c loadbit.c menu.c spline.c windows.c widget.c asc24.c
  group BSP
    ../code/BSP/: BSP.C isr.c
    ../code/BSP/FWLIB/: gpio.c uart.c wdog.c sys.c ftm.c spi.c flash.c rtc.c adc.c pit.c
    ../code/BSP/UART/: bsp_uart.c
    ../code/BSP/flash/: memory.c
    ../code/BSP/systick/: systick.c
  group DevDriver
    ../code/devdriver/SSD1906/: ssd1906_hw_fb16b.c ligsen.c
    ../code/devdriver/ili9340/: ili9340.c
    ../code/devdriver/WFG/: wave.c
    ../code/devdriver/relay/: relay.c
    ../code/devdriver/ADG/: adg.c
    ../code/devdriver/rtc/: realtime.c
    ../code/devdriver/AD7687/: ad7687.c
  group Startup
    ../code/startup/: startup_MK60D10.s system_MK60D10.c
target Boot_MK60D10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: project +hex
  AfterMake: as above
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
